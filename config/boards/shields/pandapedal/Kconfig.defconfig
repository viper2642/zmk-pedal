## config/boards/shields/pandapedal/Kconfig.defconfig
```kconfig
if SHIELD_PANDAPEDAL

   config ZMK_KEYBOARD_NAME
      	  default "Le Page Turner"
endif
```
